<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\program\mm32f327x_g9p.ewp</path>
    </project>
    <batchBuild />
</workspace>
